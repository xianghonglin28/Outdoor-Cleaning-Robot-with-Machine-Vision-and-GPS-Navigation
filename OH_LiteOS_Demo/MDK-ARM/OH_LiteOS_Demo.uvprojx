# Keil uVision project OH_LiteOS_Demo.uvprojx, settings and files
target OH_LiteOS_Demo (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: OH_LiteOS_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../LiteOS_M;../LiteOS_M/include;../LiteOS_M/arch/include;../LiteOS_M/arch/arm/include;../LiteOS_M/utils;../LiteOS_M/utils/include;../LiteOS_M/utils/securec;..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ./: oled.c oled.h oledfont.c oledfont.h
    ../Core/Src/: main.c gpio.c i2c.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group LiteOS_M
    ../LiteOS_M/src/: los_event.c los_init.c los_mux.c los_queue.c los_sched.c los_sem.c los_sortlink.c los_swtmr.c los_task.c los_tick.c
    ../LiteOS_M/src/mm/: los_membox.c los_memory.c
    ../LiteOS_M/arch/arm/cortex-m4/iar/: los_context.c los_interrupt.c los_mpu.c los_timer.c los_dispatch.S los_exc.S
    ../LiteOS_M/utils/: los_debug.c los_error.c
    ../LiteOS_M/utils/securec/: memcpy_s.c memset_s.c strncpy_s.c
software components: CMSIS:CORE 6.1.0
